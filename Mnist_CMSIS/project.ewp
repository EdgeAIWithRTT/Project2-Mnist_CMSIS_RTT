# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; ARM_MATH_CM7; __FPU_PRESENT; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread/components/libc/compilers/common; packages/CMSIS-latest/CMSIS_5/CMSIS/DSP/Include; packages/CMSIS-latest/CMSIS_5/CMSIS/Core/Include; rt-thread/components/finsh; libraries/HAL_Drivers/config; libraries/STM32H7xx_HAL/CMSIS/Include; rt-thread/libcpu/arm/common; packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Include; rt-thread/libcpu/arm/cortex-m7; rt-thread/components/drivers/include; libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Include; board; libraries/HAL_Drivers; board/CubeMX_Config/Inc; .; rt-thread/include; libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CMSIS
    packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
    packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
    packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c
    packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
    packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
    packages/CMSIS-latest/CMSIS_5/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c
